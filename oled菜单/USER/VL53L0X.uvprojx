# Keil uVision project VL53L0X.uvprojx, settings and files
target VL53L0X (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VL53L0X +hex
  c flags: Optim=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\USMART;..\HARDWARE\VL53L0X\core\inc;..\HARDWARE\VL53L0X\platform\inc;..\HARDWARE\VL53L0X\demo;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/: pid.c pwm.c exti.c tim.c OLED_I2C.c codetab.h
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_i2c.c
  group VL53L0X
    ../HARDWARE/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../HARDWARE/VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
  group VL53L0X_demo
    ../HARDWARE/VL53L0X/demo/: vl53l0x.c vl53l0x_cali.c vl53l0x_gen.c vl53l0x_it.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
